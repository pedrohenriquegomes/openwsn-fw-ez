# IAR project 03oos_openwsn.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430fn.h
  General.OGChipSelectMenu: MSP430F1611 MSP430F1611
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: FORCETOPOLOGY
  ICC430.CCDiagSuppress: Pa050
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..\..\..\bsp\boards\; ..\..\..\bsp\boards\telosb\; ..\..\..\bsp\chips\; ..\..\..\bsp\chips\cc2420\; ..\..\..\bsp\chips\sht11\; ..\..\..\drivers\; ..\..\..\drivers\common\; ..\..\..\drivers\telosb\; ..\..\..\inc\; ..\..\..\kernel\; ..\..\..\openstack\; ..\..\..\openstack\02a-MAClow\; ..\..\..\openstack\02b-MAChigh\; ..\..\..\openstack\cross-layers\; ..\..\..\openapps\; ..\..\..\openapps\uinject\
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430f1611.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptStrategy: 0
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group application
    ../../common/03oos_openwsn/: 03oos_openwsn.c 03oos_openwsn.h
  group bsp/boards
    ../../../bsp/boards/: board.h bsp_timer.h debugpins.h eui64.h i2c.h leds.h radio.h radiotimer.h sctimer.h sensors.h spi.h toolchain_defs.h uart.h
  group bsp/boards/telosb
    ../../../bsp/boards/telosb/: adc_sensor.c adc_sensor.h board.c board_info.h bsp_timer.c debugpins.c eui64.c leds.c radiotimer.c sensors.c spi.c uart.c
  group bsp/chips/cc2420
    ../../../bsp/chips/cc2420/: cc2420.c cc2420.h radio.c
  group bsp/chips/sht11
    ../../../bsp/chips/sht11/: sht11.c sht11.h
  group drivers
    ../../../drivers/common/: openhdlc.c openhdlc.h opensensors.c opensensors.h openserial.c openserial.h opentimers.c opentimers.h
  group inc
    ../../../inc/: opendefs.h
  group kernel
    ../../../kernel/: scheduler.h
  group kernel/openos
    ../../../kernel/openos/: scheduler.c
  group openapps
    ../../../openapps/: openapps.c openapps.h
  group openapps/uinject
    ../../../openapps/uinject/: uinject.c uinject.h
  group openstack
    ../../../openstack/: openstack.c openstack.h
  group openstack/02a-MAClow
    ../../../openstack/02a-MAClow/: adaptive_sync.c adaptive_sync.h blacklist.c blacklist.h IEEE802154E.c IEEE802154E.h topology.c topology.h
  group openstack/02b-MAChigh
    ../../../openstack/02b-MAChigh/: ext_schedule.c neighbors.c neighbors.h schedule.c schedule.h sixtop.c sixtop.h
  group openstack/cross-layers
    ../../../openstack/cross-layers/: idmanager.c idmanager.h openqueue.c openqueue.h openrandom.c openrandom.h packetfunctions.c packetfunctions.h
